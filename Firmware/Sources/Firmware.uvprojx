# Keil uVision project Firmware.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M0519VE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Firmware
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Library\Device\Nuvoton\M0519\Include;..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc;..\..\Library\Custom
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M0519.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M0519/Source/: system_M0519.c
    ../../Library/Device/Nuvoton/M0519/Source/ARM/: startup_M0519.s
  group Sources
    ./: main.c FMC_USER.c ISP_USER.c
  group Library
    ../../Library/StdDriver/src/: retarget.c clk.c uart.c fmc.c sys.c gpio.c timer.c
    ../../Library/Custom/: crc16.c
